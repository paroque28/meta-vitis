FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI_append = " file://containers-kmeta;type=kmeta;name=containers-kmeta;destsuffix=containers-kmeta"   
